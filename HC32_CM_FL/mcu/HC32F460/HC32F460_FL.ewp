# IAR project HC32F460_FL.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: __HC32F460_FL__
  ICCARM.CCIncludePath2: ..\..\source\framework2; ..\..\source; $PROJ_DIR$
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: FlashHC32F46x.out
  ILINK.IlinkIcfFile: HC32F460_ram.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group framework
    ../../source/framework2/: flash_loader.c flash_loader_asm.s
    ../../source/: FlashHC32.c
    ./: hc32f460_drv.c
