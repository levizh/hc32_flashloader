# IAR project HC32M423_FL.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: __HC32M423_FL__
  ICCARM.CCIncludePath2: ..\..\source\framework2; ..\..\source; $PROJ_DIR$
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: HC32M423_FL.srec
  ILINK.IlinkOutputFile: FlashHC32M423.out
  ILINK.IlinkIcfFile: HC32M423_ram.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group framework
    ../../source/framework2/: flash_loader.c flash_loader_asm.s
    ../../source/: FlashHC32.c
    ./: hc32m423_drv.c
